# Keil uVision project project.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::.\ARM_5.06u7)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\DEVICE_LIB\inc;..\SYSTEM;..\USER;..\HARDWARE;..\FreeRTOS\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s
  group DEVICE_LIB
    ../DEVICE_LIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_iwdg.c stm32f4xx_rtc.c stm32f4xx_pwr.c
    ../HARDWARE/: sys.c sys.h
  group SYSTEM
    ../SYSTEM/: system_stm32f4xx.c
  group HARDWARE
    ./: uart.h uart.c delay.h delay.c dht11.h dht11.c rtc.c rtc.h w25q128.c w25q128.h iic.c iic.h
    ../HARDWARE/: bmp.h oled.c oled.h oledfont.h
  group USER
    ./: main.c stm32f4xx_it.c
  group FreeRTOS
    ../FreeRTOS/source/: heap_4.c list.c port.c queue.c tasks.c

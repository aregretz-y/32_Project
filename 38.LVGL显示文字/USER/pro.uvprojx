# Keil uVision project pro.uvprojx, settings and files
target pro (5060960::V5.06 update 7 (build 960)::.\ARM_5.06u7)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,LV_CONF_INCLUDE_SIMPLE,LV_LVGL_H_INCLUDE_SIMPLE
  c include: ..\CMSIS;..\DEVICE_LIB\inc;..\SYSTEM;..\USER;..\HARDWARE\LED;..\HARDWARE\DELAY;..\HARDWARE\KEY;..\HARDWARE\USART;..\HARDWARE\IIC;..\HARDWARE\OLED;..\HARDWARE\SPI;..\HARDWARE\RC522;..\HARDWARE\LIGHT;..\HARDWARE\RTC;..\HARDWARE\steeringengine;..\HARDWARE\LCD;..\HARDWARE\TOUCH;..\HARDWARE\DHT11;..\LVGL\lvgl;..\LVGL\lvgl\porting;..\FREERTOS\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s
  group DEVICE_LIB
    ../DEVICE_LIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_fsmc.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DELAY/: delay.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/TOUCH/: touch.c ott2001a.c gt9147.c ft5206.c ctiic.c
    ../HARDWARE/DHT11/: dht11.c
  group SYSTEM
    ../SYSTEM/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group USER
    ./: main.c stm32f4xx_it.c
  group LVGL_core
    ../LVGL/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group LVGL_draw
    ../LVGL/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group LVGL_extra
    ../LVGL/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../LVGL/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../LVGL/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../LVGL/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../LVGL/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../LVGL/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../LVGL/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../LVGL/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../LVGL/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../LVGL/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LVGL/lvgl/src/extra/widgets/led/: lv_led.c
    ../LVGL/lvgl/src/extra/widgets/list/: lv_list.c
    ../LVGL/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../LVGL/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../LVGL/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LVGL/lvgl/src/extra/widgets/span/: lv_span.c
    ../LVGL/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LVGL/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../LVGL/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../LVGL/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../LVGL/lvgl/src/extra/widgets/win/: lv_win.c
    ../LVGL/lvgl/src/extra/: lv_extra.c
  group LVGL_font
    ../LVGL/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group LVGL_hal
    ../LVGL/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LVGL_misc
    ../LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group LVGL_widgets
    ../LVGL/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL_porting
    ../LVGL/lvgl/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group FREERTOS
    ../FREERTOS/source/: heap_4.c list.c port.c queue.c tasks.c
  group UI
    ../UI/: 1.c
  group FONT
    ../UI/: my_font.c
